# Keil uVision project 电池STC8程序.uvproj, settings and files
target Executor_STC8H (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: executor_stc8h +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  asm include: .\src
  group Executor Source
    ./src/: main.c ADC.c capacity.c STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_I2C_Isr.c STC8G_H_NVIC.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8H_PWM.c
  group Bridge Source
    ../protocol/: main.c protocol.c
    ./src/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_NVIC.c STC8G_H_UART.c STC8G_H_UART_Isr.c
target Bridge_STC8H (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: bridge_stc8h +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;..\protocol
  asm include: .\src;..\protocol
